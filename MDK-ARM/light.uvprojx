# Keil uVision project light.uvprojx, settings and files
target light (6140000::V6.14::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: light +hex
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: STM32G030xx
  c include: ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\user;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group sys
    ../user/: sys.c delay.c uart.c adc.c timer.c gpio.c spi.c lcd.c lcd_init.c dma.c osc.c
  group core
    ./: main.c
    ../Core/Src/: system_stm32g0xx.c
